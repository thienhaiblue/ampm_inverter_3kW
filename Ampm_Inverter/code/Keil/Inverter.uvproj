# Keil uVision project Inverter.uvproj, settings and files
target Inverter_LPC1758 (ARM-ADS)
  device: LPC1758 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Inverter +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__ , RUN_OK
  c include: ..\inc;..\Drivers\include;..\Core\CM3\CoreSupport;..\Core\CM3\DeviceSupport\NXP\LPC17xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS-CM3
    ../Core/CM3/CoreSupport/: core_cm3.c
    ../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Main
    ../src/: main.c delay.c application.c table_sin.c
  group Sensors
    ../src/: sensor.c
  group Power
    ../src/: power.c
  group Filter
    ../src/: filter.c
  group BUZZER
    ../src/: tone.c
  group Drivers
    ../Drivers/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
target Inverter_LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Inverter +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Debug (ARM-ADS)
  device: LPC1758 NXP (founded by Philips)
  cpu: as above
  output: Inverter +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
